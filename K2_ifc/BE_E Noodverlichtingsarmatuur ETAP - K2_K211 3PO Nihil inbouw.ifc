Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-15T09:16:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 15 09:16:35 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{003E857B-FA32-485E-8093-E5B4A9E51F1C}\ifc * Database version: 5507 * Database creation date: Wed Jun 15 09:16:34 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 15 09:16:35 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 15 09:16:35 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: K211 3PO Nihil inbouw, Dummy:K211 3PO Nihil inbouw:239166
In: Level 1
Type - Material: Glass, BE_DFT Referentievlak
Type - Constraints - Default Elevation: 1000 mm; WT_H Aansluitstuk: K2H21: K2H21; WT_H Base_hoogte: 57.5 mm; WT_H Breedte: 161.37 mm; WT_H Haakse wandmontage: no; WT_H Halve breedte: 89.65 mm; WT_H Halve breedte negatief: -89.65 mm; WT_H Halve hoogte negatief: -28.75 mm; WT_H Halve lengte negatief: -179.4 mm; WT_H Lengte: 322.92 mm; WT_H Opbouw: no; WT_H Optiek: Lens; WT_H Parallelle wandmontage: no; WT_H Permanent: yes; WT_H Referentie: Inbouw; WT_H Signalisatiemogelijkheden_type: geen; WT_H Straal pictogram: 1.5 mm; WT_H Verschuiving pictogram wand: 160 mm
Type - Dimensions - BE_G Breedte: 179.3 mm; BE_G Hoogte: 996 mm; BE_G Lengte: 358.8 mm
Type - Electrical - WT_I Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 0 W
Type - Identity Data - BE_I Bestelcode: K211/3PO; Cost: 0; Description: Noodverlichtingsarmatuur; Manufacturer: Etap; Model: K1; Type Name: K211 3PO Nihil inbouw; WT_I BaseKeynote: 68.8
Type - Materials and Finishes - WT_V Materiaal_reflector: Glass
Type - Model Properties - WT_I Autonomie: *57; WT_I Batterij type: NiMh 1,2V 1,25Ah; WT_I Kleur: grijs; WT_I Lamptype: Lamp Led; WT_I Optiek: lens; WT_I Permanent_Niet permanent: perm.; WT_I Specifieke uitvoering: voor buiten (t >= -15°C); WT_I Uitvoering: inbouw; WT_I Werking: Decentraal systeem; WT_I Zelftest: EST
Type - Other - Category: Lighting Fixtures; Family Name: Dummy
Type - Photometrics - WT_H Lichtbron: Lichtbron K2: K211_3PO_ELZONDER; WT_I Lumen: 162
Pset_ManufacturerTypeInformation - Manufacturer: Etap
Pset_DistributionFlowElementCommon - Reference: K211 3PO Nihil inbouw
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Code toebehoren: 0; WT_H Rotatie pictogram: 0 deg; WT_H Rotatie pictogram wand: 180 deg
Construction - WT_V Beschermkorf: Beschermkorf K2: Geen; WT_V Pendelhoogte: 150 mm
Dimensions - Area: 0.982317 m2; Volume: 0.0788728 m3
Electrical - WT_c1 Kringnummer: 0
Electrical - Circuiting - Electrical Data: c1_Power - Balanced 230 V/1-0 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Graphics - BE_G Pictogram: BE_G_ANN Pictogram: Geen; WT_I Signalisatiemogelijkheden: geen; WT_V Pictogram andere richting: no
Identity Data - Mark: 113
Other - Family: Dummy: K211 3PO Nihil inbouw; Family and Type: Dummy: K211 3PO Nihil inbouw; Schedule Level: Level: Level 1; Type: Dummy: K211 3PO Nihil inbouw; Type Id: Dummy: K211 3PO Nihil inbouw; WT_V 3 uur autonomie: no; WT_V Antidiefstalvergrendeling: no; WT_V EBS module KCADB01: no; WT_V EBS module KCFLEX1: no; WT_V NiMH batterijen voor niet permanente armaturen: no; WT_V Potentiaalvrij contact_niet voor ESM: no; WT_V Uitvoering voor combinatie met E3E5 lijnsysteem_enkel voor opbouwarmaturen: no
Phasing - Phase Created: 469492

# IfcFlowTerminal: K2H21, K2H21:K2H21:239168
In: Level 1
Type - Constraints - Default Elevation: 1000 mm
Type - Identity Data - BE_I Bestelcode: K2H21; Cost: 0; Description: inbouwkader; Manufacturer: Etap; Model: K2; Type Name: K2H21
Type - Other - Category: Lighting Fixtures; Family Name: K2H21
Pset_ManufacturerTypeInformation - Manufacturer: Etap
Pset_DistributionFlowElementCommon - Reference: K2H21
Constraints - Moves With Nearby Elements: no
Construction - WT_V Pendelhoogte: 150 mm
Dimensions - Volume: 0.0000519788 m3
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 115
Other - Family: K2H21: K2H21; Family and Type: K2H21: K2H21; Type: K2H21: K2H21; Type Id: K2H21: K2H21
Phasing - Phase Created: 469492
